<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\..\..\02. AS5045\&#x41F;&#x440;&#x43e;&#x433;&#x440;&#x430;&#x43C;&#x43C;&#x430;\&#x412;&#x435;&#x440;&#x441;&#x438;&#x44F; 1.0\_prj_spi\Project\AS5045.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\KMA200.ewp</path>
  </project>
  <batchBuild/>
</workspace>


