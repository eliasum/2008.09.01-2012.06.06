# IAR project KMA200.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: _SYSTEM_BUILD; FRMWRI_BUFSIZE=32; QSORT_MAXSIZE=32; SCANF_MAXLINE=32
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: lnk0t.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.LCHeapSize: 0x20
  General.SCCStackSize: 0x50
  General.SCRStackSize: 32
  ICCAVR.CCDefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm168p.xcl
  group header
    ../: common.h crc8.h main.h terminal.h
  group sourse
    ../: crc8.c main.c terminal.c
